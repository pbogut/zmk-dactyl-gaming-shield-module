## boards/shields/dactyl_gaming/Kconfig.defconfig
```kconfig
if SHIELD_DACTYL_GAMING

config ZMK_KEYBOARD_NAME
    default "Dactyl Gamingf"

endif
```
